# Keil uVision project SPI.uvprojx, settings and files
target SPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\Libraries\CMSIS\Include;..\..\Libraries\CORE;..\..\Libraries\CMSIS\Lib\ARM;..\..\Libraries\AIR32F10xLib\inc;.\ADS1256;.\INC;.\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c air32f10x_it.c
    ../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
    ./SRC/: common.c systemconfig.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../Libraries/CORE/: core_cm3.c startup_air32f10x.s
  group FWLib
    ../../Libraries/AIR32F10xLib/src/: air32f10x_dma.c air32f10x_gpio.c air32f10x_rcc.c air32f10x_spi.c air32f10x_usart.c misc.c
  group AD1256
    ./ADS1256/: ADS1256.C
